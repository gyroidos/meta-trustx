FILESEXTRAPATHS:prepend:gyroidos-cml := "${THISDIR}/${PN}:"
