FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-pv-display-handle-error-of-tcgetpgrp-in-pv_in_foregr.patch"
