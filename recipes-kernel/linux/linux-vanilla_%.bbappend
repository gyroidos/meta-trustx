include linux-gyroidos.inc
