SRC_URI += "\
"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
