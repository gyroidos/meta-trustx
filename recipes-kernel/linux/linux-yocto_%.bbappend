FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://trustx.cfg" 
SRC_URI += "file://netfilter.cfg" 
