linux-vanilla_%.bbappend