EXTRA_OECONF:append = "--enable-static=yes"
